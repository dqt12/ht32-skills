# Keil uVision project cmsis_dap_ht32.uvprojx, settings and files
target HT32F52352 ()
  device: HT32F52352
