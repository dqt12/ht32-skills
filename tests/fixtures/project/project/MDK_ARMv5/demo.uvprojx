# Keil uVision project demo.uvprojx, settings and files
target Demo ()
  output: demo
target Other ()
  output: other
